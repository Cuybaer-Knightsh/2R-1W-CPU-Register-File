

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO reg_file_2r1w 
  PIN clk 
    ANTENNAPARTIALMETALAREA 0.0593 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2988 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 2.1934 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 11.3688 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 10.8016 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 55.728 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.864 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 33.8275 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 175.65 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 0.453704 LAYER Via6 ;
  END clk
  PIN rst_n 
    ANTENNAPARTIALMETALAREA 4.4379 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.8996 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 11.8 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 24.5986 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 127.292 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.455814 LAYER Via4 ;
  END rst_n
  PIN write_enable 
    ANTENNAPARTIALMETALAREA 1.1786 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.0552 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 15.3072 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 78.8112 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.12 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 155.638 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 801.79 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via4 ;
  END write_enable
  PIN write_addr[2] 
    ANTENNAPARTIALMETALAREA 1.913 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.9144 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 29.6658 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 153.99 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.98 LAYER Via3 ;
  END write_addr[2]
  PIN write_addr[1] 
    ANTENNAPARTIALMETALAREA 2.89 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.9328 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 49.7192 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 257.186 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.98 LAYER Via3 ;
  END write_addr[1]
  PIN write_addr[0] 
    ANTENNAPARTIALMETALAREA 1.6339 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.4852 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.12 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 68.8492 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 353.99 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.98 LAYER Via3 ;
  END write_addr[0]
  PIN write_data[31] 
    ANTENNAPARTIALMETALAREA 1.6052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.4384 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 29.8483 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 155.99 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[31]
  PIN write_data[30] 
    ANTENNAPARTIALMETALAREA 2.4578 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.8232 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 44.72 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 232.37 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[30]
  PIN write_data[29] 
    ANTENNAPARTIALMETALAREA 1.8072 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3888 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 33.8767 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 175.13 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[29]
  PIN write_data[28] 
    ANTENNAPARTIALMETALAREA 3.3906 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.532 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 59.595 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 307.25 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[28]
  PIN write_data[27] 
    ANTENNAPARTIALMETALAREA 3.3906 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.532 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 63.7783 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 328.91 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[27]
  PIN write_data[26] 
    ANTENNAPARTIALMETALAREA 3.9194 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.34 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 79.23 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 409.85 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[26]
  PIN write_data[25] 
    ANTENNAPARTIALMETALAREA 1.6448 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5536 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 35.9067 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 185.57 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[25]
  PIN write_data[24] 
    ANTENNAPARTIALMETALAREA 1.6448 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5536 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 37.26 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 192.53 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[24]
  PIN write_data[23] 
    ANTENNAPARTIALMETALAREA 2.335 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1032 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 43.4783 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 224.51 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[23]
  PIN write_data[22] 
    ANTENNAPARTIALMETALAREA 4.6086 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.796 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 85.3033 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 439.61 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[22]
  PIN write_data[21] 
    ANTENNAPARTIALMETALAREA 4.5294 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.5656 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 79.2533 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 411.33 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[21]
  PIN write_data[20] 
    ANTENNAPARTIALMETALAREA 3.8778 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.0376 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 69.32 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 357.41 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[20]
  PIN write_data[19] 
    ANTENNAPARTIALMETALAREA 2.336 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1968 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 42.02 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 216.83 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[19]
  PIN write_data[18] 
    ANTENNAPARTIALMETALAREA 1.523 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.9272 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 50.7933 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 262.13 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[18]
  PIN write_data[17] 
    ANTENNAPARTIALMETALAREA 0.0418 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2088 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.6912 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6432 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.7 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 34.5456 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 124.95 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 646.31 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER Via5 ;
  END write_data[17]
  PIN write_data[16] 
    ANTENNAPARTIALMETALAREA 4.8928 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.2576 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 90.04 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 463.97 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[16]
  PIN write_data[15] 
    ANTENNAPARTIALMETALAREA 4.4056 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.752 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 76.5217 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 394.55 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[15]
  PIN write_data[14] 
    ANTENNAPARTIALMETALAREA 3.6748 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.9936 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 67.1617 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 346.31 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[14]
  PIN write_data[13] 
    ANTENNAPARTIALMETALAREA 0.2854 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4616 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2852 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5552 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 9.2172 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 47.4912 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 163.574 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 844.97 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER Via5 ;
  END write_data[13]
  PIN write_data[12] 
    ANTENNAPARTIALMETALAREA 0.0418 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2088 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1634 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9288 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 12.993 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 66.9096 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 239.302 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1234.55 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER Via5 ;
  END write_data[12]
  PIN write_data[11] 
    ANTENNAPARTIALMETALAREA 0.123 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6264 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.7618 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.292 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.4052 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 43.3152 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 169.17 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 873.77 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER Via5 ;
  END write_data[11]
  PIN write_data[10] 
    ANTENNAPARTIALMETALAREA 2.153 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.0664 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.407 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1816 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 91.7567 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 474.17 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.98 LAYER Via4 ;
  END write_data[10]
  PIN write_data[9] 
    ANTENNAPARTIALMETALAREA 0.1636 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8352 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1228 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.72 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.309 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 37.6776 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 131.298 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 678.99 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER Via5 ;
  END write_data[9]
  PIN write_data[8] 
    ANTENNAPARTIALMETALAREA 0.7726 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9672 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2852 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5552 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.0248 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 36.216 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 133.742 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 691.67 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER Via5 ;
  END write_data[8]
  PIN write_data[7] 
    ANTENNAPARTIALMETALAREA 0.123 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6264 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.5694 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.0168 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 3.249 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 16.7976 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 74.195 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 385.43 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER Via5 ;
  END write_data[7]
  PIN write_data[6] 
    ANTENNAPARTIALMETALAREA 1.2192 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.264 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1228 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.72 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 3.6144 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 18.6768 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 80.28 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 416.33 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER Via5 ;
  END write_data[6]
  PIN write_data[5] 
    ANTENNAPARTIALMETALAREA 0.0418 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2088 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.1272 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.1712 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 17.8244 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 91.7568 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 306.292 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1579.07 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER Via5 ;
  END write_data[5]
  PIN write_data[4] 
    ANTENNAPARTIALMETALAREA 0.0418 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2088 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1228 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.72 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 15.0636 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 77.5584 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 288.012 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1484.81 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER Via5 ;
  END write_data[4]
  PIN write_data[3] 
    ANTENNAPARTIALMETALAREA 2.7214 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.9896 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.0566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5224 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 13.3178 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 68.58 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 237.272 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1224.11 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER Via5 ;
  END write_data[3]
  PIN write_data[2] 
    ANTENNAPARTIALMETALAREA 0.7726 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9672 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0831 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.522 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.3752 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 32.8752 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 118.87 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 615.29 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER Via5 ;
  END write_data[2]
  PIN write_data[1] 
    ANTENNAPARTIALMETALAREA 0.0418 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2088 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.5288 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.808 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.9992 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 41.2272 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 167.56 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 865.49 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.30667 LAYER Via5 ;
  END write_data[1]
  PIN write_data[0] 
    ANTENNAPARTIALMETALAREA 2.5786 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.356 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 69.1917 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 356.75 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.653333 LAYER Via3 ;
  END write_data[0]
  PIN read_addr1[2] 
    ANTENNAPARTIALMETALAREA 4.4682 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.0616 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 32.7104 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 170 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.735 LAYER Via4 ;
  END read_addr1[2]
  PIN read_addr1[1] 
    ANTENNAPARTIALMETALAREA 4.387 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.644 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.432 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 28.9274 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 150.567 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.02537 LAYER Via4 ;
  END read_addr1[1]
  PIN read_addr1[0] 
    ANTENNAPARTIALMETALAREA 4.5494 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.4792 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 35.4092 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 181.24 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.898333 LAYER Via4 ;
  END read_addr1[0]
  PIN read_addr2[2] 
    ANTENNAPARTIALMETALAREA 2.9727 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.282 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 56.1496 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 290.965 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.06167 LAYER Via4 ;
  END read_addr2[2]
  PIN read_addr2[1] 
    ANTENNAPARTIALMETALAREA 4.0612 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.88 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 32.85 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 167.27 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.735 LAYER Via4 ;
  END read_addr2[1]
  PIN read_addr2[0] 
    ANTENNAPARTIALMETALAREA 0.0418 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2088 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.6912 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6432 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.432 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 23.9331 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 123.247 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.744074 LAYER Via5 ;
  END read_addr2[0]
  PIN read_data1[31] 
    ANTENNADIFFAREA 0.5364 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 15.9164 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 81.8496 LAYER Metal3 ;
  END read_data1[31]
  PIN read_data1[30] 
    ANTENNAPARTIALMETALAREA 15.551 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 79.9704 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNADIFFAREA 0.5364 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.7406 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.7544 LAYER Metal4 ;
  END read_data1[30]
  PIN read_data1[29] 
    ANTENNAPARTIALMETALAREA 2.9321 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.0732 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.4926 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.0504 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.5364 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 13.196 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 67.9536 LAYER Metal5 ;
  END read_data1[29]
  PIN read_data1[28] 
    ANTENNAPARTIALMETALAREA 0.0418 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2088 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.61 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2256 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 13.4802 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 69.4152 LAYER Metal5 ;
  END read_data1[28]
  PIN read_data1[27] 
    ANTENNAPARTIALMETALAREA 2.0312 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.44 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.67 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.1056 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.5364 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 10.1916 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 52.5024 LAYER Metal5 ;
  END read_data1[27]
  PIN read_data1[26] 
    ANTENNAPARTIALMETALAREA 2.356 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1104 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.4147 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2212 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.9074 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 51.0408 LAYER Metal5 ;
  END read_data1[26]
  PIN read_data1[25] 
    ANTENNAPARTIALMETALAREA 2.5996 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3632 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 9.9074 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 51.0408 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.5364 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 13.5614 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 69.8328 LAYER Metal5 ;
  END read_data1[25]
  PIN read_data1[24] 
    ANTENNAPARTIALMETALAREA 2.4778 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7368 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.8112 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 45.4032 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.5364 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 13.8456 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 71.2944 LAYER Metal5 ;
  END read_data1[24]
  PIN read_data1[23] 
    ANTENNAPARTIALMETALAREA 2.2342 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.484 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 9.1766 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 47.2824 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.5364 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 12.5058 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 64.404 LAYER Metal5 ;
  END read_data1[23]
  PIN read_data1[22] 
    ANTENNAPARTIALMETALAREA 1.3816 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.0992 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0831 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.522 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 10.7677 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 55.4652 LAYER Metal5 ;
  END read_data1[22]
  PIN read_data1[21] 
    ANTENNAPARTIALMETALAREA 1.4628 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5168 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.5376 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 33.7104 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.5364 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 10.557 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 54.3816 LAYER Metal5 ;
  END read_data1[21]
  PIN read_data1[20] 
    ANTENNAPARTIALMETALAREA 2.1607 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.106 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.5303 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.53 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.5364 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 10.2728 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 52.92 LAYER Metal5 ;
  END read_data1[20]
  PIN read_data1[19] 
    ANTENNAPARTIALMETALAREA 0.0418 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2088 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.5438 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.028 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.5364 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 15.3478 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 79.02 LAYER Metal5 ;
  END read_data1[19]
  PIN read_data1[18] 
    ANTENNAPARTIALMETALAREA 0.123 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6264 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.7724 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0608 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 15.3478 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 79.02 LAYER Metal5 ;
  END read_data1[18]
  PIN read_data1[17] 
    ANTENNAPARTIALMETALAREA 0.2448 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2528 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.9348 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.896 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 13.399 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 68.9976 LAYER Metal5 ;
  END read_data1[17]
  PIN read_data1[16] 
    ANTENNAPARTIALMETALAREA 2.4372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.528 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.7468 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.072 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 6.0098 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 30.996 LAYER Metal5 ;
  END read_data1[16]
  PIN read_data1[15] 
    ANTENNAPARTIALMETALAREA 0.2448 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2528 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1228 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.72 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 8.4864 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 43.7328 LAYER Metal5 ;
  END read_data1[15]
  PIN read_data1[14] 
    ANTENNAPARTIALMETALAREA 0.6508 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3408 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.437 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.6216 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 7.715 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 39.7656 LAYER Metal5 ;
  END read_data1[14]
  PIN read_data1[13] 
    ANTENNAPARTIALMETALAREA 0.0418 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2088 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.437 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.6216 LAYER Metal4 ;
  END read_data1[13]
  PIN read_data1[12] 
    ANTENNADIFFAREA 0.2976 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 5.401 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.7704 LAYER Metal3 ;
  END read_data1[12]
  PIN read_data1[11] 
    ANTENNAPARTIALMETALAREA 0.1636 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8352 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.3002 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.7752 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 7.918 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 40.8096 LAYER Metal5 ;
  END read_data1[11]
  PIN read_data1[10] 
    ANTENNAPARTIALMETALAREA 0.0418 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2088 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.016 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.3136 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.9542 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 25.5672 LAYER Metal5 ;
  END read_data1[10]
  PIN read_data1[9] 
    ANTENNADIFFAREA 0.2976 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 4.3048 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.1328 LAYER Metal3 ;
  END read_data1[9]
  PIN read_data1[8] 
    ANTENNADIFFAREA 0.2976 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.2173 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.6284 LAYER Metal3 ;
  END read_data1[8]
  PIN read_data1[7] 
    ANTENNAPARTIALMETALAREA 1.95 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.0224 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 11.0848 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 57.096 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.5364 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 5.4008 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 27.864 LAYER Metal5 ;
  END read_data1[7]
  PIN read_data1[6] 
    ANTENNAPARTIALMETALAREA 0.6914 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5496 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1228 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.72 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.5364 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 6.8218 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 35.172 LAYER Metal5 ;
  END read_data1[6]
  PIN read_data1[5] 
    ANTENNADIFFAREA 0.2976 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.424 LAYER Metal3 ;
  END read_data1[5]
  PIN read_data1[4] 
    ANTENNADIFFAREA 0.2976 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.575 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.468 LAYER Metal3 ;
  END read_data1[4]
  PIN read_data1[3] 
    ANTENNAPARTIALMETALAREA 1.6252 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.352 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 12.5058 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 64.404 LAYER Metal4 ;
  END read_data1[3]
  PIN read_data1[2] 
    ANTENNAPARTIALMETALAREA 1.341 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.8904 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 15.6726 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 80.6904 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.5364 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 3.452 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 17.8416 LAYER Metal5 ;
  END read_data1[2]
  PIN read_data1[1] 
    ANTENNAPARTIALMETALAREA 1.747 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9784 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 15.9568 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 82.152 LAYER Metal4 ;
  END read_data1[1]
  PIN read_data1[0] 
    ANTENNAPARTIALMETALAREA 7.6746 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 39.4632 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNADIFFAREA 0.5364 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 15.7944 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 81.3168 LAYER Metal4 ;
  END read_data1[0]
  PIN read_data2[31] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.4707 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.9316 LAYER Metal4 ;
  END read_data2[31]
  PIN read_data2[30] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.6596 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.2432 LAYER Metal4 ;
  END read_data2[30]
  PIN read_data2[29] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.4416 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.9792 LAYER Metal4 ;
  END read_data2[29]
  PIN read_data2[28] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.6508 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3408 LAYER Metal4 ;
  END read_data2[28]
  PIN read_data2[27] 
    ANTENNAPARTIALMETALAREA 1.2598 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.4728 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 3.4926 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 18.0504 LAYER Metal5 ;
  END read_data2[27]
  PIN read_data2[26] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.2042 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.044 LAYER Metal4 ;
  END read_data2[26]
  PIN read_data2[25] 
    ANTENNAPARTIALMETALAREA 2.2342 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.484 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 1.219 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.3576 LAYER Metal5 ;
  END read_data2[25]
  PIN read_data2[24] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 13.1566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 67.7448 LAYER Metal4 ;
  END read_data2[24]
  PIN read_data2[23] 
    ANTENNAPARTIALMETALAREA 0.0418 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2088 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.9348 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.896 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via5 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 14.9012 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 76.7232 LAYER Metal6 ;
  END read_data2[23]
  PIN read_data2[22] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.4566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 33.1992 LAYER Metal4 ;
  END read_data2[22]
  PIN read_data2[21] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 15.551 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 79.9704 LAYER Metal4 ;
  END read_data2[21]
  PIN read_data2[20] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 12.1504 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 62.4816 LAYER Metal4 ;
  END read_data2[20]
  PIN read_data2[19] 
    ANTENNAPARTIALMETALAREA 0.0418 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2088 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.9754 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1048 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via5 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 11.166 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 57.5136 LAYER Metal6 ;
  END read_data2[19]
  PIN read_data2[18] 
    ANTENNAPARTIALMETALAREA 8.4054 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 43.2216 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNADIFFAREA 0.2976 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 3.9392 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 20.3472 LAYER Metal5 ;
  END read_data2[18]
  PIN read_data2[17] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 9.3798 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 48.2328 LAYER Metal4 ;
  END read_data2[17]
  PIN read_data2[16] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 12.709 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 65.3544 LAYER Metal4 ;
  END read_data2[16]
  PIN read_data2[15] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 9.7868 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 50.4144 LAYER Metal4 ;
  END read_data2[15]
  PIN read_data2[14] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 7.8468 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.3488 LAYER Metal4 ;
  END read_data2[14]
  PIN read_data2[13] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 8.9738 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 46.1448 LAYER Metal4 ;
  END read_data2[13]
  PIN read_data2[12] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 10.3948 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 53.4528 LAYER Metal4 ;
  END read_data2[12]
  PIN read_data2[11] 
    ANTENNADIFFAREA 0.5364 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 15.2262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 78.3 LAYER Metal4 ;
  END read_data2[11]
  PIN read_data2[10] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 14.8618 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 76.5144 LAYER Metal4 ;
  END read_data2[10]
  PIN read_data2[9] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 13.815 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 71.0424 LAYER Metal4 ;
  END read_data2[9]
  PIN read_data2[8] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 15.0232 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 77.256 LAYER Metal4 ;
  END read_data2[8]
  PIN read_data2[7] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.4126 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.6328 LAYER Metal4 ;
  END read_data2[7]
  PIN read_data2[6] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.7268 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.5344 LAYER Metal4 ;
  END read_data2[6]
  PIN read_data2[5] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 12.5882 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 64.8216 LAYER Metal4 ;
  END read_data2[5]
  PIN read_data2[4] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 7.0656 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.3312 LAYER Metal4 ;
  END read_data2[4]
  PIN read_data2[3] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.2792 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.144 LAYER Metal4 ;
  END read_data2[3]
  PIN read_data2[2] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.559 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.1544 LAYER Metal4 ;
  END read_data2[2]
  PIN read_data2[1] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.4372 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.528 LAYER Metal4 ;
  END read_data2[1]
  PIN read_data2[0] 
    ANTENNADIFFAREA 0.2976 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.1361 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.2108 LAYER Metal4 ;
  END read_data2[0]
  PIN SE 
    ANTENNAPARTIALMETALAREA 0.711 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7512 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 118.493 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 613.25 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.98 LAYER Via4 ;
  END SE
  PIN scan_in 
    ANTENNAPARTIALMETALAREA 2.5796 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.4496 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.06 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 82.9533 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 432.34 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.98 LAYER Via4 ;
  END scan_in
  PIN scan_out 
    ANTENNADIFFAREA 0.3024 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.1274 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.0776 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.276 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 30.3659 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 157.042 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.724348 LAYER Via4 ;
  END scan_out
END reg_file_2r1w

END LIBRARY
